# Keil uVision project Smart Access Control System.uvprojx, settings and files
target Smart Access Control System (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart Access Control System
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,WIFI,ANIMATION
  c misc: --no-multibyte-chars
  c include: .\Startup;.\Stm32F10x_StdPeriph_Driver\inc;.\Stm32F10x_StdPeriph_Driver\src;.\Hardware;.\System;.\User;.\RTOS\inc;.\RTOS\src;.\RTOS\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: stm32f10x.h core_cm3.c core_cm3.h startup_stm32f10x_md.s system_stm32f10x.c system_stm32f10x.h
  group Hardware
    ./Hardware/: OLED.c OLED.h Key.c OLED_Data.c OLED_Data.h driver_rc522.c driver_rc522.h driver_as608.c driver_as608.h Servo.c Servo.h W25Q64BV.c W25Q64BV.h body_infrared.c body_infrared.h
    ./hardware/: Key.h Beep.c Beep.h
    ./System/: Light.c Light.h
  group Stm32F10x_StdPeriph_Driver
    ./Stm32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./Stm32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/: Delay.c Delay.h UART1.c UART1.h UART2.c UART2.h UART3.c UART3.h PWM.c PWM.h
    ./system/: Tim.c Tim.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Menu.c Menu.h RFID.c RFID.h Finger.c Finger.h ESP01S_WIFIMOUDLE.c ESP01S_WIFIMOUDLE.h Storage.c Storage.h Face.c Face.h
    ./user/: typedef.h
  group RTOS\src
    ./RTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS\inc
    ./RTOS/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group RTOS\portable
    ./RTOS/portable/: FreeRTOSConfig.h heap_4.c port.c portmacro.h
